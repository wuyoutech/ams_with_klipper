# Keil uVision project gd32f303.uvprojx, settings and files
target App (6220000::V6.22::ARMCLANG)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f303
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: .\src\Application;.\src\CMSIS;.\src\CMSIS\GD\GD32F30x\Include;.\src\Peripherals\Include;..\..\AppData\Local\Keil_v5\ARM\ARMCLANG\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ./src/Application/: main.c gd32f30x_it.c systick.c led.c filament_buffer.c feeder.c hall.c
  group CMSIS
    ./src/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ./src/Peripherals/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Stratup
    ./src/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s startup_gd32f30x_hd.s startup_gd32f30x_cl.s
target Bootloader (ARM-ADS)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: as above
  output: gd32f303
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
